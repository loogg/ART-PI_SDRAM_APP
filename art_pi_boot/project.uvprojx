# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, USE_HAL_DRIVER, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: packages\agile_upgrade-latest\inc;packages\agile_upgrade-latest\porting\rt-thread;applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;packages\fastlz-v1.0.1;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;.;rt-thread\include;libraries\samples;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\quicklz-v1.0.1;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;packages\tinycrypt-latest\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group agile_upgrade
    packages/agile_upgrade-latest/src/: agile_upgrade_aes.c agile_upgrade_fastlz.c agile_upgrade_crc.c agile_upgrade.c agile_upgrade_quicklz.c
    packages/agile_upgrade-latest/adapter/: agile_upgrade_file.c
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c waitqueue.c pipe.c ringbuffer.c workqueue.c ringblk_buf.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: soft_rtc.c rtc.c
    rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/port/: agile_upgrade_sdram.c filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: drv_mpu.c board.c
    libraries/drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_wlan.c drv_sdio.c drv_lcd.c drv_usart.c drv_common.c
  group fastlz
    packages/fastlz-v1.0.1/: fastlz.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Kernel
    rt-thread/src/: idle.c mem.c device.c thread.c components.c ipc.c irq.c timer.c object.c scheduler.c kservice.c clock.c
  group quicklz
    packages/quicklz-v1.0.1/: quicklz.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_sdram.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cryp.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_usart.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group TinyCrypt
    packages/tinycrypt-latest/src/: tiny_sha1.c tiny_base64.c tiny_aes.c tiny_sha2.c tiny_md5.c
